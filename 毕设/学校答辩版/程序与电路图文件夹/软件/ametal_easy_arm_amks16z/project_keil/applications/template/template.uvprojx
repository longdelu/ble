# Keil uVision project template.uvprojx, settings and files
target debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL16Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: img_keil_template +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: AM_VDEBUG MPU6050_DMP ARM_MATH_CM0PLUS
  c include: ..\..\..\ametal\board;..\..\..\ametal\CMSIS\Include;..\..\..\ametal\common\include;.\user_code;.\user_config\include;..\..\..\ametal\amks16z\drivers\include;..\..\..\ametal\amks16z\hw\include;.\user_code\matrix_key;.\user_code\mpu6050;.\user_code\demo_example;.\user_code\mpu6050_dmp;.\user_code\mpu6050_imu
  asm define: AM_CORTEX_M0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group common
    ../../../ametal/common/source/: am_i2c.c am_ringbuf.c am_spi.c am_uart.c am_uart_int.c am_uart_ringbuf.c am_adc.c am_buzzer_pwm.c am_dac.c am_led.c
  group startup
    ./startup/: startup_MKL16Z4.S
  group board
    ../../../ametal/board/: am_delay.c am_board.c am_debug.c am_system.c am_board.h am_system.h
  group drivers
    ../../../ametal/amks16z/drivers/source/: amdr_adc.c amdr_dac.c amdr_gpio.c amdr_int.c amdr_spi.c amdr_tpm_cap.c amdr_tpm_pwm.c amdr_tpm_timing.c amdr_uart.c amdr_pit_timing.c amdr_lptmr_timing.c amdr_dma.c amdr_wdt.c amdr_ftfa.c amdr_pmu.c amdr_rtc.c amdr_tsi.c amdr_i2c.c amdr_clk.c
  group hw
    ../../../ametal/amks16z/hw/source/: amhw_adc.c amhw_dac.c amhw_uart.c amhw_spi.c amhw_ftfa.c amhw_i2s.c
  group user_config
    ./user_config/source/: amdr_hwconfig_adc.c amdr_hwconfig_dac.c amdr_hwconfig_dma.c amdr_hwconfig_gpio.c amdr_hwconfig_i2c.c amdr_hwconfig_int.c amdr_hwconfig_lptmr_timing.c amdr_hwconfig_pit_timing.c amdr_hwconfig_pmu.c amdr_hwconfig_rtc.c amdr_hwconfig_spi.c amdr_hwconfig_tsi.c amdr_hwconfig_tpm_cap.c amdr_hwconfig_tpm_pwm.c amdr_hwconfig_tpm_timing.c amdr_hwconfig_uart.c amdr_hwconfig_wdt.c amdr_hwconfig_clk.c
  group user_code
    ./user_code/: readme.c
    ./user_code/mpu6050/: am_mpu6050.c
    ./user_code/matrix_key/: am_key.c
    ./user_code/mpu6050_dmp/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ./user_code/demo_example/: demo_std_key.c demo_std_send_obser_mpu6050.c demo_std_low_fly_mouse.c demo_std_imu_mpu6050.c
    ./user_code/mpu6050_imu/: am_imu.c
